# Keil uVision project 工程.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 智能手环 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;.\src
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./src/: ls138.c delay.c iic.c smg.c
